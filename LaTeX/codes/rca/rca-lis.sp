 ***** job concluded******  
 ******************** hspice basic gates modeling ********************

 ****** job statistics summary tnom=  25.000 temp=  25.000 ******

 ******  HSPICE Threads Information  ******

  Command Line Threads Count :     1
  Available CPU Count        :    16
  Actual Threads Count       :     1


 ******  Circuit Statistics  ******
  # nodes       =     180 # elements   =     316
  # resistors   =       0 # capacitors =       0 # inductors   =       0
  # mutual_inds =       0 # vccs       =       0 # vcvs        =       0
  # cccs        =       0 # ccvs       =       0 # volt_srcs   =       2
  # curr_srcs   =       0 # diodes     =       0 # bjts        =       0
  # jfets       =       0 # mosfets    =     288 # U elements  =       0
  # T elements  =       0 # W elements =       0 # B elements  =       0
  # S elements  =       0 # P elements =       0 # va device   =       0
  # vector_srcs =      26 # N elements =       0


 ******  Runtime Statistics (seconds)  ******

  analysis           time    # points   tot. iter  conv.iter
  op point           0.09           1         246
  transient       8501.36      524288    42112878    14293979 rev=   1314970
  readin             0.10
  errchk             0.24
  setup              0.00
  output             0.00


           peak memory used        138.01 megabytes
           total cpu time         8501.81 seconds
           total elapsed time     8501.84 seconds
           job started at     16:57:06 04/15/2026
           job ended   at     19:18:48 04/15/2026
           job total runtime      8501.84 seconds
