          ***** job concluded
 ******  
 ******************** hspice basic gates modeling ********************

 ****** job statistics summary tnom=  25.000 temp=  25.000 ******

  ******  HSPICE Threads Information  ******

  Command Line Threads Count :     1
  Available CPU Count        :    16
  Actual Threads Count       :     1


  ******  Circuit Statistics  ******
  # nodes       =     243 # elements   =     448
  # resistors   =       1 # capacitors =       0 # inductors   =       0
  # mutual_inds =       0 # vccs       =       0 # vcvs        =       0
  # cccs        =       0 # ccvs       =       0 # volt_srcs   =      13
  # curr_srcs   =       0 # diodes     =       0 # bjts        =       0
  # jfets       =       0 # mosfets    =     408 # U elements  =       0
  # T elements  =       0 # W elements =       0 # B elements  =       0
  # S elements  =       0 # P elements =       0 # va device   =       0
  # vector_srcs =      26 # N elements =       0


  ******  Runtime Statistics (seconds)  ******

  analysis           time    # points   tot. iter  conv.iter
  op point           0.04           1          62
  transient         89.11     6500001      373435      127375 rev=     10186
  readin             0.11
  errchk             0.02
  setup              0.00
  output             0.00


           peak memory used         76.53 megabytes
           total cpu time           89.27 seconds
           total elapsed time       89.30 seconds
           job started at     23:40:46 06/08/2026
           job ended   at     23:42:15 06/08/2026
           job total runtime        89.30 seconds


  lic: Release hspice token(s) 
 lic: total license checkout elapse time:        0.03(s)